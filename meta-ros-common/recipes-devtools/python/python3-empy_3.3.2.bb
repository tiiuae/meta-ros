require python-empy.inc

inherit setuptools3_legacy
